# Keil uVision project Demo.uvproj, settings and files
target Core (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Demo
  c flags: Optimize=8 SizeSpeed=1
  c include: ../Core/Inc
  group STARTUP
    ./: STARTUP.A51
  group Lib
    ../Core/Lib/: lib-kalman.LIB
  group Src
    ./: main.c
