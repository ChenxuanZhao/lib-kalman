# Keil uVision project lib-kalman.uvproj, settings and files
target Core (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lib-kalman (library)
  c flags: Optimize=8 SizeSpeed=1
  c include: ../Core/Inc
  group Src
    ../Core/Src/: lib_kalman.c
